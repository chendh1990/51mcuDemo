# Keil uVision project Door_bell.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Door_bell +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\OS;..\include
  asm include: ..\OS
  group OS
    ../OS/: OS_CORE.C OS_Q.C OS_SEM.C
  group OS_CPU
    ../OS_CPU/: OS_CPU_C.C OS_CPU_A.ASM
  group APP
    ../source/: timer.c tone.c uart.c eeprom.c key.c LED.C main.c PCA.c power.c RF_remote.c sys.c SysClk.c HistoryLog.c WIFI.c
